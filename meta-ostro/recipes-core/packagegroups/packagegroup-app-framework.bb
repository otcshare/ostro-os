SUMMARY = "Ostro Application Framework"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = " \
    iot-app-fw \
"
