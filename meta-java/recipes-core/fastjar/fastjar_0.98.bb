require fastjar.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=59530bdf33659b29e73d4adb9f9f6552"

SRC_URI += "file://jartool.patch"

SRC_URI[md5sum] = "d2d264d343d4d0e1575832cc1023c3bf"
SRC_URI[sha256sum] = "f156abc5de8658f22ee8f08d7a72c88f9409ebd8c7933e9466b0842afeb2f145"

