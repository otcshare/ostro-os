require openjdk-7-release-03b21.inc

PR = "${INC_PR}.0"

ICEDTEA = "icedtea-2.1.3"

SRC_URI[iced.md5sum] = "200e74ad440f9c4bfa21cc2bd94b4325"
SRC_URI[iced.sha256sum] = "1929e57eb6718d30735e1e04e9e129457f845f7d7a8404b2b028740d0779ddb6"

HOTSPOT_CHANGESET = "a456d0771ba0"
SRC_URI[hotspot.md5sum] = "23c46cbb8e8a2e04dafa6ef63bc810c4"
SRC_URI[hotspot.sha256sum] = "09a64fca0beff0759ef1b461d63ed6a00e43032972781bb3a55e49d8b93f67d0"

CORBA_CHANGESET = "79ee8535bc51"
SRC_URI[corba.md5sum] = "0e04317a6a74fea66ecac51c6171413c"
SRC_URI[corba.sha256sum] = "f61dad8d484e4a9e645b7fb73da87bc44f9986a074629154f37ed46be05f5b84"

JAXP_CHANGESET = "77e7219c7424"
SRC_URI[jaxp.md5sum] = "27ea9ad4c7a4c43eb1ccab8a0f365a50"
SRC_URI[jaxp.sha256sum] = "9cfbc0efaface20f7188870b9bf5b0ebc73d745cd9a49d013cd4e81ba223ccdc"

JAXWS_CHANGESET = "d92eda447bca"
SRC_URI[jaxws.md5sum] = "4fb688cb0e2c703dfdedca187bb94070"
SRC_URI[jaxws.sha256sum] = "6d0858d46b68d6e8488e70d1675e5b656aeb4ef51e8ee4e330e77219f92c1c0c"

JDK_CHANGESET = "d7ecb57d3c61"
SRC_URI[jdk.md5sum] = "0e90a9d980d44998083343a3a7614bb5"
SRC_URI[jdk.sha256sum] = "11146763409098a42dd9896f3fb7e7324a58c5cff5298009eb347ad26abeed51"

LANGTOOLS_CHANGESET = "fd2fdb20d858"
SRC_URI[langtools.md5sum] = "48335bb031d4c75e75823e2d70f17ef5"
SRC_URI[langtools.sha256sum] = "3a4039348aa49547fffa96563b77b704c72e2ac3ead2c132843ba1e9fe4dbad2"

OPENJDK_CHANGESET = "f89009ada191"
SRC_URI[openjdk.md5sum] = "c26bbb33addfaeb14d28a1329b4b5a3e"
SRC_URI[openjdk.sha256sum] = "54a0ef02b56b265b4122324e08a33c42ececbf2a300ada260611e7b6ccdba96d"
