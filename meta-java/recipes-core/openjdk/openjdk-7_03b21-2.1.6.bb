require openjdk-7-release-03b21.inc

PR = "${INC_PR}.0"

SRC_URI[iced.md5sum] = "f1118898beda7f94ce1731b78e9d2890"
SRC_URI[iced.sha256sum] = "e6a65923acb29b87b9f8492adc6f00152b489441e788b64e2869301cc7fa29ba"

HOTSPOT_CHANGESET = "d8b22e079abe"
SRC_URI[hotspot.md5sum] = "378a2933f0484c2d460ecc7c1bed5a09"
SRC_URI[hotspot.sha256sum] = "28883ebefcfff1ba8b356a7fabf8e449c25fe7fffe1d563f1f58f887100063f0"

CORBA_CHANGESET = "4afc0be5b3c6"
SRC_URI[corba.md5sum] = "edda29d73e9ff797109b5cc5febdcce9"
SRC_URI[corba.sha256sum] = "813e02861d89147c0547f4608fe69b0abd153cf548bf1f21ef9d16ea0a6d683e"

JAXP_CHANGESET = "efa047bf59e9"
SRC_URI[jaxp.md5sum] = "91f0dd58dcdaf787a9fdcc87feb8240a"
SRC_URI[jaxp.sha256sum] = "20d745c58117d1eaa061edb689bb7569b512ac8fb3d0f3518b5fa8b17ba7012e"

JAXWS_CHANGESET = "52bbe659af64"
SRC_URI[jaxws.md5sum] = "785f18b5b50bf6c6d761b2ccb45d52e6"
SRC_URI[jaxws.sha256sum] = "d8acabf54c1a4fe02e45ac4bdfe1ff9f3e7a3abc12884fcacd580bce9063a7c5"

JDK_CHANGESET = "78fbbfe20edb"
SRC_URI[jdk.md5sum] = "fded1abb32ea304b63636b452b4e3340"
SRC_URI[jdk.sha256sum] = "7eeee7d8479f97ab0eb66be3845224b8b4073de8829ed819175faf9ca2f3b5ca"

LANGTOOLS_CHANGESET = "ac6983a8bd4a"
SRC_URI[langtools.md5sum] = "d333560b41d639829dc8e4e06084dee5"
SRC_URI[langtools.sha256sum] = "47db36264b345939176d1a5f36df84ad56d7fae76ce647ea1b619f7df0eb1eda"

OPENJDK_CHANGESET = "7de37e3bcca6"
SRC_URI[openjdk.md5sum] = "1b4ce1d38cc01254c48f8bde213fb0fe"
SRC_URI[openjdk.sha256sum] = "9bdf6a874cb7ad4a5cbebb21cef9bebe8c0b8463a1c155df916eb311da9ca7a0"
