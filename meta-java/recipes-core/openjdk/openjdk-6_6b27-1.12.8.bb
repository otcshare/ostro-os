require openjdk-6-release-6b27.inc

PR = "${INC_PR}.4"

SRC_URI[iced.md5sum] = "7712c4b3b9f8092aa8c7b5cad0b46d06"
SRC_URI[iced.sha256sum] = "c2ad74af29af774f778675d3fde952f4defebb2be44f565253d788e2e7af39d4"
