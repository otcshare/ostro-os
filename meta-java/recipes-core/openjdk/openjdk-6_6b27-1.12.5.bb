require openjdk-6-release-6b27.inc

PR = "${INC_PR}.2"

SRC_URI[iced.md5sum] = "2299fde9f315c7feb561c2975aa232b1"
SRC_URI[iced.sha256sum] = "c61d6eb2f98d5c4059bb6eb6d808dd0954cf7d35c14290e5c77c3d7db75d2b35"
