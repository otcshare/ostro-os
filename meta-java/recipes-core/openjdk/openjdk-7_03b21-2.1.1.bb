require openjdk-7-release-03b21.inc

PR = "${INC_PR}.0"

ICEDTEA = "icedtea-2.1.1"

SRC_URI[iced.md5sum] = "32859fa5f7337d58ae848311e2a94761"
SRC_URI[iced.sha256sum] = "4a015cf3fb8fb9aa6b3ce4a41fd9bc5dcb417a1885a10a01e92d0cc7a5ffdc65"

HOTSPOT_CHANGESET = "8b7c4c5f6ba9"
SRC_URI[hotspot.md5sum] = "cb45a8f19d77acc1f4f48e75e36a27fe"
SRC_URI[hotspot.sha256sum] = "22866990d143e76ced94b76defa3051e5e5d9a51fd272d63daa0df272d6406a2"

CORBA_CHANGESET = "338c21646c76"
SRC_URI[corba.md5sum] = "32d4851fca9c205fe1710a453c32a8fe"
SRC_URI[corba.sha256sum] = "10425cbbb439551293a7a96a128f25ce408c38826bef8562f4c2d65d3134a1d3"

JAXP_CHANGESET = "7a8825b15df6"
SRC_URI[jaxp.md5sum] = "a0982b6df79739127871e355a40ca5a6"
SRC_URI[jaxp.sha256sum] = "297c8dbeed5afa5395b6be06b17282d53f8a888c2909074dfc1605afc0daf1c2"

JDK_CHANGESET = "d5ddeffc4651"
SRC_URI[jdk.md5sum] = "27c28d6be213df818490e69f12efe475"
SRC_URI[jdk.sha256sum] = "e83e6234842376147a4c32451f23d629ba107e908ebdb0f367657f9cc6c1be98"
