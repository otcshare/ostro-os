require openjdk-6-release-6b32.inc

PR = "${INC_PR}.0"

SRC_URI[iced.md5sum] = "95d61221d0be3616c8c04d164df524a4"
SRC_URI[iced.sha256sum] = "302b17575ad98bbf6a1d4d8768d2ea1f1b070f153c660ebe493b6509d56ed0e7"
