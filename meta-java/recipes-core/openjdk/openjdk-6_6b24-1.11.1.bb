require openjdk-6-release-6b24.inc

PR = "${INC_PR}.0"

ICEDTEA = "icedtea6-1.11.1"

SRC_URI[iced.md5sum] = "e51d9d2f0328cc5aa7a00943abd96ed6"
SRC_URI[iced.sha256sum] = "bafb0e21e1edf5ee22871b13dbc0a8a0d3efd894551fb91d5f59783069b6912c"
