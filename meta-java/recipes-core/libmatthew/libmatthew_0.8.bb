require libmatthew.inc

PR = "r0"

LIC_FILES_CHKSUM = "file://COPYING;md5=48a42f2f9747f02bf40a0bce2655b509"

SRC_URI = "http://pkgs.fedoraproject.org/repo/pkgs/libmatthew-java/libmatthew-java-0.8.tar.gz/8455b8751083ce25c99c2840609271f5/libmatthew-java-${PV}.tar.gz \
          "
#           file://Makefile-0.7.patch"
SRC_URI[md5sum] = "8455b8751083ce25c99c2840609271f5"
SRC_URI[sha256sum] = "05d1d3d9b5e33bd3642102aae10bba904e296c5c01a10854200ad4df349c8dfa"

