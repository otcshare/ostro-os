require jakarta-commons.inc
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=3b83ef96387f14655fc854ddc3c6bd57"

PR = "${INC_PR}.1"

DESCRIPTION = "Java Object-pooling API"

SRC_URI = "http://archive.apache.org/dist/commons/pool/source/${BP}-src.tar.gz"

SRC_URI[md5sum] = "4dc988ee16e1471799af97763297b41b"
SRC_URI[sha256sum] = "ca4452f2a2ce2daf6eaa1743ded2d3b36013200c48e3f2117b65584ca5cc1d9b"
