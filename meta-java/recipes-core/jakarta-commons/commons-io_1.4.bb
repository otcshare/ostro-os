require jakarta-commons.inc
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=fd707e76aa29b6984fbe80629ec55f78"

PR = "${INC_PR}.1"

DESCRIPTION = "Java library with utility classes, stream implementations, file filters and endian classes"

SRC_URI = "http://archive.apache.org/dist/commons/io/source/${BP}-src.tar.gz"

SRC_URI[md5sum] = "24b228f2d0c40ffed9204cdab015bccf"
SRC_URI[sha256sum] = "eca986497f7b4d1b1ec41821b1b5df827bb31fc14833e4449cfa8bcd5d7f29bb"
