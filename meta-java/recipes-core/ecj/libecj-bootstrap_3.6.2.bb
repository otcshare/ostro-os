require libecj-bootstrap.inc

SRC_URI = " http://mirrors.ibiblio.org/pub/mirrors/eclipse/eclipse/downloads/drops/R-3.6.2-201102101200/ecjsrc-${PV}.zip"

SRC_URI[md5sum] = "3f3ca1973dd7a21780525c9ffba7a263"
SRC_URI[sha256sum] = "94f2095d38d71b414a593ec56847008bec267a926ec935959fecdde44f98467f"

