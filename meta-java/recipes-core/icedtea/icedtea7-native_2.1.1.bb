require openjdk-7-release-03b147.inc

PR = "${INC_PR}.1"

ICEDTEA = "icedtea-2.1.1"

SRC_URI[iced.md5sum] = "32859fa5f7337d58ae848311e2a94761"
SRC_URI[iced.sha256sum] = "4a015cf3fb8fb9aa6b3ce4a41fd9bc5dcb417a1885a10a01e92d0cc7a5ffdc65"

