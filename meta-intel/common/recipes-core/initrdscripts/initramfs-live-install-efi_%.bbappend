FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
PACKAGE_ARCH_intel-x86-common = "${INTEL_COMMON_PACKAGE_ARCH}"
