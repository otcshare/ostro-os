COMPATIBLE_MACHINE = "intel-core2-32"
