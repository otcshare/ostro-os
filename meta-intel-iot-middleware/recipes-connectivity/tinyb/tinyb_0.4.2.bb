require tinyb.inc

SRC_URI = "git://github.com/intel-iot-devkit/tinyb.git;protocol=git;rev=df5204ea64ddcd79e23ab3c4ec8edbf87f65d34e \
           file://0001-Release-0.4.2.patch \
          "
