require mraa.inc

SRC_URI = "git://github.com/intel-iot-devkit/mraa.git;protocol=git;rev=d8024bb516bf2d895eaff6f92115835d7ef704a2"

HELLO_WORLD_I_THINK_YOU_ARE_GREAT="balbhalbksdflfjasd;lfkjasldkfja;lsdkfasldfa;sdfasd;fasdfsld"
