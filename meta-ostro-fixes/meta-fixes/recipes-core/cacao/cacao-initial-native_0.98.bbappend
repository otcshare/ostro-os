FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = "file://cacao-0.9.8-do_not_rely_on_absolute_paths.patch"
